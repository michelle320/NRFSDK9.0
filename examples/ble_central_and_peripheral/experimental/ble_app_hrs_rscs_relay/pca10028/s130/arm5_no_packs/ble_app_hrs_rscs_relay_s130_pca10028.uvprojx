# Keil uVision project ble_app_hrs_rscs_relay_s130_pca10028.uvprojx, settings and files
target nrf51422_xxac_s130 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s130 +hex
  c flags: Optim=4 OneElfS=1
  c define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD S130 BOARD_PCA10028 BSP_UART_SUPPORT NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\..\components\softdevice\s130\headers;..\..\..\..\..\..\bsp;..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\components\ble\device_manager;..\..\..\..\..\..\..\components\ble\ble_advertising;..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs;..\..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_bas;..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs;..\..\..\..\..\..\..\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\ble\ble_db_discovery;..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\..\RTT
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x24000
  memory RVCT9: RAM 0x20002800 size 0x5800
  group Application
    ../../../: main.c
  group Board Support
    ../../../../../../bsp/: bsp.c bsp_btn_ble.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../../../components/ble/ble_advertising/: ble_advertising.c
    ../../../../../../../components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../../../../../components/ble/ble_services/ble_bas_c/: ble_bas_c.c
    ../../../../../../../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../../../../../../components/ble/ble_services/ble_hrs/: ble_hrs.c
    ../../../../../../../components/ble/ble_services/ble_hrs_c/: ble_hrs_c.c ble_bp_c.c
    ../../../../../../../components/ble/ble_services/ble_rscs/: ble_rscs.c
    ../../../../../../../components/ble/ble_services/ble_rscs_c/: ble_rscs_c.c
    ../../../../../../../components/ble/device_manager/: device_manager_central.c
  group nRF_Drivers
    ../../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../../../../components/softdevice/s130/doc/: s130_nrf51822_1.0.0_licence_agreement.txt
    ../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group RTT
    ../../../../../../../RTT/: SEGGER_RTT.c
  group ::Device
    RTE/Device/nRF51422_xxAC/: arm_startup_nrf51.s system_nrf51.c
target flash_softdevice (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.1.0
  cpu: as above
  output: s130_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..\..\..\config
  asm define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 3.40.0, Device:Startup 7.2.1
